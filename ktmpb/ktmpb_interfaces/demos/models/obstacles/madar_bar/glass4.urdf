Commit message: move with 2 arms

File: ktmpb/ktmpb_interfaces/demos/models/obstacles/madar_bar/glass4.urdf (robot description, URDF)
Before this commit: robot glass4, 1 links, 0 joints
Links:
- link base: mass 0.05 -> None
